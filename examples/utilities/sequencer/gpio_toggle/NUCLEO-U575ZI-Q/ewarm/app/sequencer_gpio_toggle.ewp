# IAR project sequencer_gpio_toggle.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.FPU2: 6
  ICCARM.CCDefines: STM32U575xx; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../generated/_release_IAR_NUCLEO-U575ZI-Q/Pre_Include_Global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../stm32u5xx_dfp/Include; ../../../../../../../stm32u5xx_drivers/hal; ../../../../../../../stm32u5xx_drivers/ll; ../../../../../../../stm32u5xx_drivers/timebases; ../../../../../../../utilities/sequencer; ../../../../../../../utilities/sequencer/template; ../../../application; ../../generated/_release_IAR_NUCLEO-U575ZI-Q; ../../generated/hal; ../../generated/utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: STM32U575xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../generated/Device/STM32U575ZIT6Q/stm32u575xi_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group arch/cmsis/CMSIS/Core/Include
    ../../../../../../../arch/cmsis/CMSIS/Core/Include/: tz_context.h
  group generated/Device/STM32U575ZIT6Q
    ../../generated/Device/STM32U575ZIT6Q/: startup_stm32u575xx.c system_stm32u5xx.c
  group generated/hal
    ../../generated/hal/: mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h stm32_ll.h stm32u5xx_hal_conf.h
  group generated/utilities
    ../../generated/utilities/: mx_seq.c mx_seq.h seq_user_conf.h
  group stm32u5xx_dfp
    ../../../../../../../stm32u5xx_dfp/: README.md
  group stm32u5xx_dfp/Include
    ../../../../../../../stm32u5xx_dfp/Include/: partition_stm32u5xx.h stm32u5xx.h
  group stm32u5xx_drivers
    ../../../../../../../stm32u5xx_drivers/: LICENSE.md README.md
  group stm32u5xx_drivers/hal
    ../../../../../../../stm32u5xx_drivers/hal/: stm32_hal.h stm32u5xx_hal_cortex.c stm32u5xx_hal_cortex.h stm32u5xx_hal_def.h stm32u5xx_hal_exti.c stm32u5xx_hal_exti.h stm32u5xx_hal_flash_itf.c stm32u5xx_hal_flash_itf.h stm32u5xx_hal_gpio.c stm32u5xx_hal_gpio.h stm32u5xx_hal_icache.c stm32u5xx_hal_icache.h stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr.h stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc.h stm32u5xx_hal_syscfg.c stm32u5xx_hal_syscfg.h stm32u5xx_hal.c stm32u5xx_hal.h
  group stm32u5xx_drivers/ll
    ../../../../../../../stm32u5xx_drivers/ll/: stm32u5xx_ll_bus.h stm32u5xx_ll_exti.h stm32u5xx_ll_flash.h stm32u5xx_ll_gpio.h stm32u5xx_ll_icache.h stm32u5xx_ll_pwr.h stm32u5xx_ll_rcc.h stm32u5xx_ll_syscfg.h
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/sequencer
    ../../../../../../../utilities/sequencer/: CONTRIBUTING.md README.md sequencer.c sequencer.h
  group utilities/sequencer/template
    ../../../../../../../utilities/sequencer/template/: seq_user_conf_template.h
