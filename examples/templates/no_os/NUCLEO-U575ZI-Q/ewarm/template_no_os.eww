<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\template_no_os.ewp</path>
    </project>
</workspace>