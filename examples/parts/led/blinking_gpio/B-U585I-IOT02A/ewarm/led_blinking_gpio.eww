<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\led_blinking_gpio.ewp</path>
    </project>
</workspace>