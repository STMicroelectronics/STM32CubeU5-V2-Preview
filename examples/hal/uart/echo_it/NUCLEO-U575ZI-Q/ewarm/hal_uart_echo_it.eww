<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\hal_uart_echo_it.ewp</path>
    </project>
</workspace>