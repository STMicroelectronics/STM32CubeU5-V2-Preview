<?xml version="1.0" encoding="UTF-8"?>
<project>
    <fileVersion>3</fileVersion>
    <configuration>
        <name>release</name>
        <toolchain>
            <name>ARM</name>
        </toolchain>
        <debug>1</debug>
        <settings>
            <name>C-SPY</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>32</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>CInput</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CEndian</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CProcessor</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCVariant</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MacOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MacFile</name>
                    <state></state>
                </option>
                <option>
                    <name>MemOverride</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MemFile</name>
                    <state>$TOOLKIT_DIR$\CONFIG\debugger\ST\STM32U585AI.ddf</state>
                </option>
                <option>
                    <name>RunToEnable</name>
                    <state>1</state>
                </option>
                <option>
                    <name>RunToName</name>
                    <state>main</state>
                </option>
                <option>
                    <name>CExtraOptionsCheck</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CExtraOptions</name>
                    <state></state>
                </option>
                <option>
                    <name>CFpuProcessor</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCDDFArgumentProducer</name>
                    <state></state>
                </option>
                <option>
                    <name>OCDownloadSuppressDownload</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDownloadVerifyAll</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCProductVersion</name>
                    <state>9.20.1.43525</state>
                </option>
                <option>
                    <name>OCDynDriverList</name>
                    <state>STLINK_ID</state>
                </option>
                <option>
                    <name>OCLastSavedByProductVersion</name>
                    <state>9.20.1.43525</state>
                </option>
                <option>
                    <name>UseFlashLoader</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CLowLevel</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCBE8Slave</name>
                    <state>1</state>
                </option>
                <option>
                    <name>MacFile2</name>
                    <state></state>
                </option>
                <option>
                    <name>CDevice</name>
                    <state>1</state>
                </option>
                <option>
                    <name>FlashLoadersV3</name>
                    <state>$TOOLKIT_DIR$\config\flashloader\ST\FlashSTM32U5xxxI.board</state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesSuppressCheck3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesPath3</name>
                    <state></state>
                </option>
                <option>
                    <name>OverrideDefFlashBoard</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesOffset1</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset2</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesOffset3</name>
                    <state></state>
                </option>
                <option>
                    <name>OCImagesUse1</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse2</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCImagesUse3</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCDeviceConfigMacroFile</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCDebuggerExtraOption</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCAllMTBOptions</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCMulticoreNrOfCores</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCMulticoreWorkspace</name>
                    <state></state>
                </option>
                <option>
                    <name>OCMulticoreSlaveProject</name>
                    <state></state>
                </option>
                <option>
                    <name>OCMulticoreSlaveConfiguration</name>
                    <state></state>
                </option>
                <option>
                    <name>OCDownloadExtraImage</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCAttachSlave</name>
                    <state>0</state>
                </option>
                <option>
                    <name>MassEraseBeforeFlashing</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCMulticoreNrOfCoresSlave</name>
                    <state>1</state>
                </option>
                <option>
                    <name>OCMulticoreAMPConfigType</name>
                    <state>0</state>
                </option>
                <option>
                    <name>OCMulticoreSessionFile</name>
                    <state></state>
                </option>
                <option>
                    <name>OCTpiuBaseOption</name>
                    <state>1</state>
                </option>
            </data>
        </settings>
        <settings>
            <name>STLINK_ID</name>
            <archiveVersion>2</archiveVersion>
            <data>
                <version>7</version>
                <wantNonLocal>1</wantNonLocal>
                <debug>1</debug>
                <option>
                    <name>OCDriverInfo</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CCSTLinkInterfaceRadio</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CCSTLinkInterfaceCmdLine</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkResetList</name>
                    <version>3</version>
                    <state>4</state>
                </option>
                <option>
                    <name>CCCpuClockEdit</name>
                    <state>160.0</state>
                </option>
                <option>
                    <name>CCSwoClockAuto</name>
                    <state>1</state>
                </option>
                <option>
                    <name>CCSwoClockEdit</name>
                    <state>2000</state>
                </option>
                <option>
                    <name>DoLogfile</name>
                    <state>0</state>
                </option>
                <option>
                    <name>LogFile</name>
                    <state>$PROJ_DIR$\cspycomm.log</state>
                </option>
                <option>
                    <name>CCSTLinkDoUpdateBreakpoints</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkUpdateBreakpoints</name>
                    <state>_call_main</state>
                </option>
                <option>
                    <name>CCSTLinkCatchCORERESET</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkCatchMMERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkCatchNOCPERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkCatchCHRERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkCatchSTATERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkCatchBUSERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkCatchINTERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkCatchSFERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkCatchHARDERR</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkCatchDummy</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkUsbSerialNo</name>
                    <state></state>
                </option>
                <option>
                    <name>CCSTLinkUsbSerialNoSelect</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkJtagSpeedList</name>
                    <version>2</version>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkDAPNumber</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkDebugAccessPortRadio</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkUseServerSelect</name>
                    <state>0</state>
                </option>
                <option>
                    <name>CCSTLinkProbeList</name>
                    <version>1</version>
                    <state>0</state>
                </option>
            </data>
        </settings>
        <debuggerPlugins>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\CMX\CmxArmPlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\CMX\CmxTinyArmPlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\FreeRtos\FreeRtosArmPlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\Mbed\MbedArmPlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\Mbed\MbedArmPlugin2.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\OpenRTOS\OpenRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SafeRTOS\SafeRTOSPlugin.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SMX\smxAwareIarArm9.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\SMX\smxAwareIarArm9BE.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$TOOLKIT_DIR$\plugins\rtos\ThreadX\ThreadXArmPlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\TargetAccessServer\TargetAccessServer.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
            <plugin>
                <file>$EW_DIR$\common\plugins\uCProbe\uCProbePlugin.ENU.ewplugin</file>
                <loadFlag>0</loadFlag>
            </plugin>
        </debuggerPlugins>
    </configuration>
</project>