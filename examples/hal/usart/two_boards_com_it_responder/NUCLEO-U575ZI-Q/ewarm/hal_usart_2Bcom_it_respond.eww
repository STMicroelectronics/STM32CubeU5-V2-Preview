<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\hal_usart_2Bcom_it_respond.ewp</path>
    </project>
</workspace>