<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\hal_usart_2B_com_it_cont\hal_usart_2B_com_it_cont.ewp</path>
    </project>
</workspace>