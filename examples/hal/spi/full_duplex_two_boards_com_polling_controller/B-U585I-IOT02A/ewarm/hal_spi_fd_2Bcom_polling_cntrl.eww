<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\hal_spi_fd_2Bcom_polling_cntrl.ewp</path>
    </project>
</workspace>