<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\fd_2b_dma_rspdr.ewp</path>
    </project>
</workspace>