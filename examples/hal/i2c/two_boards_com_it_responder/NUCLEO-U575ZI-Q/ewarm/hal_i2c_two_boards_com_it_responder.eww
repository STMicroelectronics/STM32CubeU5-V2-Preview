<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\hal_i2c_two_boards_com_it_responder.ewp</path>
    </project>
</workspace>