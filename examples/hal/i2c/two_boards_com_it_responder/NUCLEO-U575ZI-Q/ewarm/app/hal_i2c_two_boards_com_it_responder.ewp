# IAR project hal_i2c_two_boards_com_it_responder.ewp, settings and files
configuration release (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32U575ZI ST STM32U575ZI
  General.FPU2: 6
  ICCARM.CCDefines: STM32U575xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../part_drivers/led/gpio; ../../../../../../../stm32u5xx_dfp/Include; ../../../../../../../stm32u5xx_drivers/hal; ../../../../../../../stm32u5xx_drivers/ll; ../../../../../../../stm32u5xx_drivers/timebases; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../../application; ../../generated/_release_IAR_NUCLEO-U575ZI-Q; ../../generated/hal; ../../generated/parts
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: STM32U575xx; _RTE_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: $PROJ_FNAME$.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../generated/Device/STM32U575ZIT6Q/stm32u575xi_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group arch/cmsis/CMSIS/Core/Include
    ../../../../../../../arch/cmsis/CMSIS/Core/Include/: tz_context.h
  group generated/Device/STM32U575ZIT6Q
    ../../generated/Device/STM32U575ZIT6Q/: startup_stm32u575xx.c system_stm32u5xx.c
  group generated/hal
    ../../generated/hal/: mx_cortex_nvic.c mx_cortex_nvic.h mx_def.h mx_gpio_default.c mx_gpio_default.h mx_hal_def.h mx_i2c1.c mx_i2c1.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_usart1.c mx_usart1.h stm32_ll.h stm32u5xx_hal_conf.h
  group generated/parts
    ../../generated/parts/: mx_led.h
  group part_drivers/led
    ../../../../../../../part_drivers/led/: CONTRIBUTING.md README.md
  group part_drivers/led/gpio
    ../../../../../../../part_drivers/led/gpio/: led.h
  group stm32u5xx_dfp
    ../../../../../../../stm32u5xx_dfp/: README.md
  group stm32u5xx_dfp/Include
    ../../../../../../../stm32u5xx_dfp/Include/: partition_stm32u5xx.h stm32u5xx.h
  group stm32u5xx_drivers
    ../../../../../../../stm32u5xx_drivers/: LICENSE.md README.md
  group stm32u5xx_drivers/hal
    ../../../../../../../stm32u5xx_drivers/hal/: stm32_hal.h stm32u5xx_hal_cortex.c stm32u5xx_hal_cortex.h stm32u5xx_hal_def.h stm32u5xx_hal_dma.c stm32u5xx_hal_dma.h stm32u5xx_hal_exti.c stm32u5xx_hal_exti.h stm32u5xx_hal_flash_itf.c stm32u5xx_hal_flash_itf.h stm32u5xx_hal_gpio.c stm32u5xx_hal_gpio.h stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c.h stm32u5xx_hal_icache.c stm32u5xx_hal_icache.h stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr.h stm32u5xx_hal_q.c stm32u5xx_hal_q.h stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc.h stm32u5xx_hal_syscfg.c stm32u5xx_hal_syscfg.h stm32u5xx_hal_uart.c stm32u5xx_hal_uart.h stm32u5xx_hal.c stm32u5xx_hal.h
  group stm32u5xx_drivers/ll
    ../../../../../../../stm32u5xx_drivers/ll/: stm32u5xx_ll_bus.h stm32u5xx_ll_dma.h stm32u5xx_ll_exti.h stm32u5xx_ll_flash.h stm32u5xx_ll_gpio.h stm32u5xx_ll_i2c.h stm32u5xx_ll_icache.h stm32u5xx_ll_pwr.h stm32u5xx_ll_rcc.h stm32u5xx_ll_syscfg.h stm32u5xx_ll_usart.h
  group UserCode
    ../../../application/: example.c example.h main.c main.h
    ../../../: README.md
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h CONTRIBUTING.md README.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c
