<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\hal_tim_timebase\hal_tim_timebase.ewp</path>
    </project>
</workspace>