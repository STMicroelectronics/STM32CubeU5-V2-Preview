<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\hal_tim_pwm_dma.ewp</path>
    </project>
</workspace>