<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app\hal_rcc_lsi_config.ewp</path>
    </project>
</workspace>